# Keil uVision project I2C.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D17 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x2FF) CLOCK(25000000)
  output: I2C +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: main.c
